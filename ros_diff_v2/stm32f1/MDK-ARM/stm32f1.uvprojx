# Keil uVision project stm32f1.uvprojx, settings and files
target stm32f1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../USER;../HARDWARE/pid;../HARDWARE/MPU6050/src;../HARDWARE/MPU6050/inc;../ROBOT/pid;..\HARDWARE\Motor;..\HARDWARE\IMU;..\HARDWARE\ENCODER;..\ROBOT\robot;..\ROBOT\filter;..\HARDWARE\Battery;..\ROBOT\speed_ramp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group USER
    ../USER/: chassis.c comHandle.c contrl.c move.c pid_debug.c pid_debug.h
  group HARDERWARE
    ../HARDWARE/MPU6050/src/: IICcom.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IMU/: imu.c
    ../HARDWARE/Battery/: battery.c
  group ROBOT
    ../ROBOT/pid/: pid.c pid.h
    ../ROBOT/robot/: robot.c
    ../ROBOT/filter/: kalman_filter.c kalman_filter.h
    ../ROBOT/speed_ramp/: speed_ramp.c
software components: CMSIS:CORE 4.3.0
